# Keil uVision project IMU_AHRS.uvproj, settings and files
target IMU_AHRS (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: IMU_AHRS +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: .\StartUp;.\User_Src;.\Lib\inc;.\HardWareDriver;.\HardWareDriver\BMP085;.\HardWareDriver\HMC5883L;.\HardWareDriver\IMU;.\HardWareDriver\LED;.\HardWareDriver\MPU6050;.\HardWareDriver\UART2;.\HardWareDriver\UARTs;.\HardWareDriver\MS5611
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ./StartUp/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
  group HardWareDriver
    ./HardWareDriver/: delay.c IOI2C.c
    ./HardWareDriver/UARTs/: UARTs.c
  group User_Src
    ./User_Src/: main.c stm32f10x_it.c
  group Lib
    ./Lib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
